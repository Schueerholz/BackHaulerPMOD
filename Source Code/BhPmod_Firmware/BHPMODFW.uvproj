# Keil uVision project BHPMODFW.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F387 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x07FF) IROM(0-0x7FFF) CLOCK(48000000)
  output: BHPMODFW +hex
  c flags: SizeSpeed=1
  group Top Level
    ./: GLOBAL.H BHPMODFW.C
    ../: BHPMODICD.H
  group Tasks
    ./: APP.H APP.C USB.H USB.C
  group Drivers
    ./: PMOD.H PMOD.C SPI.H SPI.C I2C.H I2C.C SERIAL.H SERIAL.C TIMER.H TIMER.C
  group Primitives
    ./: USB_API.H USBX_F38X.LIB DELAYS.H DELAYS.C STARTUP.A51
